Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: e7e8a878-34ce-44a2-865c-8918c8ed5df8.ifc
Time: 2026-08-11T15:54:50
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Exclusief 700 x 1400mm
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAAK9ym8AGAAAAj-wCAAWxXwAAPHsBAHQGAADA6wIAAOsCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIA1OwCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAJFYAAAFabkAAGQwAADGpwAAo60AAL8lAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAK9ym8AGAAAAj-wCAAWxXwAAPHsBAHQGAADA6wIAAOsCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIA1OwCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAJFYAAAFabkAAGQwAADGpwAAo60AAL8lAAAAAA)); STABU2: 32.32.11; lengte: 1380 mm; inbouwhoogte: 240 mm; inbouwlengte: 1400 mm; luchtdoorlatendheid klasse: 4; U-waarde: 0,58 w/m²·k; breedte: 680 mm; max. belasting: 200 kg; NAA.K.T: samengesteld_product_generiek; bediening: handmatig; theoretische levensduur: 50; serie: Schaartrap Exclusief; inbouwbreedte: 700 mm; merk: Storax; beweegbaar: True; omranding: hout; luik: hout; trap: schaarladder Storax - Schaarladder 350mm
